# Keil uVision project CH32F10x.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: CH32F103R8 WCH
  pack: Keil.WCH32F1xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CH32F10x
  AfterMake: cmd.exe /C copy CH32F10x.axf ..\CH32F1xx_64.FLM
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FLASH_MEM, CH32F1xx_64_1024
  c include: ..\..\Flash
  asm include: ..\..
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Source Group 1
    ./: FlashDev.c FlashPrg.c
